# IAR project Bootloader.ewp, settings and files
configuration MiCOKit-3162 (ARM)
  General.OGChipSelectEditMenu: STM32F205ZG ST STM32F205ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; SIZE_OPTIMIZE; BOOTLOADER; NO_MICO_RTOS
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\Bootloader; ..\..\..\..\include; ..\..\..\..\MICO; ..\..\..\..\Board\MK3162; ..\..\..\..\Platform\include; ..\..\..\..\Platform\Cortex-M3; ..\..\..\..\Platform\Cortex-M3\CMSIS; ..\..\..\..\Platform\MCU\STM32F2xx\peripherals; ..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_StdPeriph_Driver\inc; ..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries; ..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_HAL_Driver\Inc; ..\..\..\..\Platform\Drivers\STM32_USB_Host_Library\Core\Inc; ..\..\..\..\Platform\Drivers\STM32_USB_Host_Library\Class\MSC\Inc; ..\..\..\..\External\FatFs\src\drivers; ..\..\..\..\External\FatFs\src; ..\..\..\..\libraries\Drivers\spi_flash; ..\..\..\..\Platform\MCU; ..\..\..\..\libraries\utilities; ..\..\..\..\mico\system; ..\..\..\..\mico\security; ..\..\..\..\libraries\Drivers; ..\..\..\..\libraries\drivers\keypad\gpio_button; ..\..\..\..\platform
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Bootloader.bin
  ILINK.IlinkOutputFile: COM.MXCHIP.SPP.out
  ILINK.IlinkIcfFile: ..\..\..\..\Board\MK3162\bootloaderLinkerForIAR.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration MICOKit-F205 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; DEBUG; BOOTLOADER; NO_MICO_RTOS; MICO_NO_WIFI
  ICCARM.CCIncludePath2: ..\..\..\..\Bootloader; ..\..\..\..\include; ..\..\..\..\MICO; ..\..\..\..\Board\MKF205; ..\..\..\..\Platform\include; ..\..\..\..\Platform\Cortex-M3; ..\..\..\..\Platform\Cortex-M3\CMSIS; ..\..\..\..\Platform\MCU\STM32F2xx\peripherals; ..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_StdPeriph_Driver\inc; ..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries; ..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_HAL_Driver\Inc; ..\..\..\..\Platform\Drivers\STM32_USB_Host_Library\Core\Inc; ..\..\..\..\Platform\Drivers\STM32_USB_Host_Library\Class\MSC\Inc; ..\..\..\..\External\FatFs\src\drivers; ..\..\..\..\External\FatFs\src; ..\..\..\..\libraries\Drivers\spi_flash; ..\..\..\..\Platform\MCU; ..\..\..\..\mico\system; ..\..\..\..\libraries\utilities; ..\..\..\..\mico\security; ..\..\..\..\libraries\Drivers; ..\..\..\..\libraries\drivers\keypad\gpio_button; ..\..\..\..\platform
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkIcfFile: ..\..\..\..\Board\MKF205\bootloaderLinkerForIAR.icf
  group Board/MiCOKit-3162
    ../../../../board/MK3162/: platform.c platform.h platform_config.h
  group Board/MICOKit-F205
    ../../../../board/MKF205/: platform.c platform.h platform_config.h
  group Bootloader
    ../../../../bootloader/: BootloaderEntrance.c Getline.c menu.c Update_for_OTA.c ymodem.c
  group include
    ../../../../include/: mico.h MicoAES.h MicoAlgorithm.h MicoPlatform.h MICORTOS.h MicoSocket.h MiCOSRPServer.h MicoWlan.h
  group include/MicoDriver
    ../../../../include/MiCODrivers/: MiCODriverAdc.h MiCODriverGpio.h MiCODriverI2c.h MiCODriverMFiAuth.h MiCODriverPwm.h MiCODriverRng.h MiCODriverRtc.h MiCODriverSpi.h MiCODriverUart.h MiCODriverWdg.h
  group libraries/Drivers/Button
    ../../../../libraries/drivers/keypad/gpio_button/: button.c
  group libraries/Drivers/SPI Flash
    ../../../../libraries/drivers/spi_flash/: spi_flash.c spi_flash_platform.c
  group libraries/utilities
    ../../../../libraries/utilities/: CheckSumUtils.c RingBufferUtils.c StringUtils.c
  group mico
    ../../../../MiCO/RTOS/NoRTOS/: rtos.c
  group Platform/Cortex-M3
    ../../../../platform/Cortex-M3/: crt0_EWARM.c hardfault.c
  group Platform/EWARM
    ../../../../platform/EWARM/: Retarget.c
  group Platform/MCU
    ../../../../platform/MCU/: mico_platform_common.c platform_nsclock.c wlan_platform_common.c
  group Platform/MCU/STM32F2xx
    ../../../../platform/MCU/STM32F2xx/: platform_init.c
  group Platform/MCU/STM32F2xx/EWARM
    ../../../../platform/MCU/STM32F2xx/EWARM/: startup_stm32f2xx_bootloader_EWARM.s
  group Platform/MCU/STM32F2xx/Peripherals
    ../../../../platform/MCU/STM32F2xx/peripherals/: platform_adc.c platform_flash.c platform_gpio.c platform_i2c.c platform_mcu_powersave.c platform_pwm.c platform_rng.c platform_rtc.c platform_spi.c platform_uart.c platform_watchdog.c
  group Platform/MCU/STM32F2xx/Peripherals/Libraries
    ../../../../platform/MCU/STM32F2xx/peripherals/libraries/: stm32f2xx_conf.h system_stm32f2xx.c
  group Platform/MCU/STM32F2xx/Peripherals/Libraries/STM32F2xx_HAL_Driver
    ../../../../platform/MCU/STM32F2xx/peripherals/libraries/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal.c stm32f2xx_hal_hcd.c stm32f2xx_ll_usb.c
  group Platform/MCU/STM32F2xx/Peripherals/Libraries/STM32F2xx_StdPeriph_Driver
    ../../../../platform/MCU/STM32F2xx/peripherals/libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
