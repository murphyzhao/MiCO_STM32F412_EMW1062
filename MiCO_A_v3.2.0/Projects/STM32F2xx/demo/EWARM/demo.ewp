# IAR project demo.ewp, settings and files
configuration MiCOKit-3162 (ARM)
  General.OGChipSelectEditMenu: STM32F205RG ST STM32F205RG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; DEBUG; MXCHIP; FreeRTOS_VERSION="9.0.0"; LwIP_VERSION_MAJOR=1; LwIP_VERSION_MINOR=4; WOLFSSL_IAR_ARM; FreeRTOS_VERSION_MAJOR=9
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\demos\application\wifi_uart; ..\..\..\..\include; ..\..\..\..\MICO; ..\..\..\..\Support; ..\..\..\..\Board\MK3162; ..\..\..\..\Platform\include; ..\..\..\..\Platform\Cortex-M3; ..\..\..\..\Platform\Cortex-M3\CMSIS; ..\..\..\..\Platform\MCU\STM32F2xx\peripherals; ..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_StdPeriph_Driver\inc; ..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries; ..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_HAL_Driver\Inc; ..\..\..\..\Platform\Drivers\STM32_USB_Host_Library\Core\Inc; ..\..\..\..\Platform\Drivers\STM32_USB_Host_Library\Class\MSC\Inc; ..\..\..\..\libraries\Drivers\spi_flash; ..\..\..\..\Platform; ..\..\..\..\Platform\MCU; ..\..\..\..\libraries\utilities; ..\..\..\..\libraries\utilities\json_c; ..\..\..\..\libraries; ..\..\..\..\MICO\core; ..\..\..\..\MICO\security; ..\..\..\..\MICO\security\Curve25519; ..\..\..\..\MICO\security\SHAUtils; ..\..\..\..\MICO\security\SRP_6a; ..\..\..\..\MICO\system; ..\..\..\..\libraries\Drivers; ..\..\..\..\libraries\daemons\homekit_server; ..\..\..\..\libraries\daemons\http_server; ..\..\..\..\MiCO\RTOS\FreeRTOS\mico\Cortex-M3; ..\..\..\..\MiCO\RTOS\FreeRTOS\mico; ..\..\..\..\MiCO\RTOS\FreeRTOS\ver9.0.0; ..\..\..\..\MiCO\RTOS\FreeRTOS\ver9.0.0\Source\include; ..\..\..\..\MiCO\RTOS\FreeRTOS\ver9.0.0\Source\portable\IAR\ARM_CM3; ..\..\..\..\MiCO\RTOS; ..\..\..\..\MiCO\system\qc_test; ..\..\..\..\MiCO\system\qc_test\internal; ..\..\..\..\platform\MCU\STM32F2xx; ..\..\..\..\MiCO\net\LwIP\ver1.4.0.rc1\src\include; ..\..\..\..\MiCO\net\LwIP\ver1.4.0.rc1\src\include\ipv4; ..\..\..\..\libraries\drivers\keypad\gpio_button; ..\..\..\..\platform; ..\..\..\..\libraries\daemons\http_server; ..\..\..\..\libraries\utilities\base64
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ..\..\..\..\MiCO\RTOS\FreeRTOS\ver9.0.0\Source\portable\IAR\ARM_CM3; ..\..\..\..\MiCO\RTOS\FreeRTOS\mico\Cortex-M3; ..\..\..\..\MiCO\RTOS\FreeRTOS\mico; ..\..\..\..\MiCO\RTOS\FreeRTOS\ver9.0.0; ..\..\..\..\board\MK3162
  OBJCOPY.OOCOutputFile: demo.bin
  ILINK.IlinkOutputFile: COM.MXCHIP.BASIC.out
  ILINK.IlinkIcfFile: ..\..\..\..\Board\MK3162\micoLinkerForIAR.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration MiCOKit-F205 (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F205ZG ST STM32F205ZG
  ICCARM.CCIncludePath2: ..\..\..\..\demos\application\wifi_uart; ..\..\..\..\include; ..\..\..\..\MICO; ..\..\..\..\Board\MKF205; ..\..\..\..\Platform\include; ..\..\..\..\Platform\Cortex-M3; ..\..\..\..\Platform\Cortex-M3\CMSIS; ..\..\..\..\Platform\MCU\STM32F2xx\peripherals; ..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_StdPeriph_Driver\inc; ..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries; ..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_HAL_Driver\Inc; ..\..\..\..\libraries\Drivers\STM32_USB_Host_Library\Core\Inc; ..\..\..\..\libraries\Drivers\STM32_USB_Host_Library\Class\MSC\Inc; ..\..\..\..\libraries\Drivers\spi_flash; ..\..\..\..\Platform\MCU; ..\..\..\..\libraries\utilities; ..\..\..\..\mico\security; ..\..\..\..\libraries\daemons\homekit_server; ..\..\..\..\libraries\daemons\http_server; ..\..\..\..\MiCO\RTOS\FreeRTOS\mico\Cortex-M3; ..\..\..\..\MiCO\RTOS\FreeRTOS\mico; ..\..\..\..\MiCO\RTOS\FreeRTOS\ver9.0.0; ..\..\..\..\MiCO\RTOS\FreeRTOS\ver9.0.0\Source\include; ..\..\..\..\MiCO\RTOS\FreeRTOS\ver9.0.0\Source\portable\IAR\ARM_CM3; ..\..\..\..\MiCO\RTOS; ..\..\..\..\MiCO\system; ..\..\..\..\MiCO\system\qc_test\internal; ..\..\..\..\MiCO\system\qc_test; ..\..\..\..\platform\MCU\STM32F2xx; ..\..\..\..\MiCO\net\LwIP\ver1.4.0.rc1\src\include; ..\..\..\..\MiCO\net\LwIP\ver1.4.0.rc1\src\include\ipv4; ..\..\..\..\libraries\drivers\keypad\gpio_button; ..\..\..\..\platform; ..\..\..\..\libraries\daemons\http_server; ..\..\..\..\libraries\utilities\base64
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\..\MiCO\RTOS\FreeRTOS\ver9.0.0; ..\..\..\..\MiCO\RTOS\FreeRTOS\ver9.0.0\Source\portable\IAR\ARM_CM3; ..\..\..\..\MiCO\RTOS\FreeRTOS\mico\Cortex-M3; ..\..\..\..\MiCO\RTOS\FreeRTOS\mico; ..\..\..\..\board\MKF205
  ILINK.IlinkIcfFile: ..\..\..\..\Board\MKF205\micoLinkerForIAR.icf
  group Application/wifi_uart
    ../../../../demos/application/wifi_uart/: LocalTcpServer.c MICOAppEntrance.c MICOBonjour.c RemoteTcpClient.c SppProtocol.c UartRecv.c
  group Board/MiCOKit-3162
    ../../../../board/MK3162/: platform.c platform.h platform_config.h
  group Board/MiCOKit-F205
    ../../../../board/MKF205/: platform.c platform.h platform_config.h
  group include
    ../../../../include/: mico.h MicoAES.h MicoAlgorithm.h MicoPlatform.h MICORTOS.h MicoSocket.h MiCOSRPServer.h MicoWlan.h
  group include/MicoDriver
    ../../../../include/MiCODrivers/: MiCODriverAdc.h MiCODriverGpio.h MiCODriverI2c.h MiCODriverMFiAuth.h MiCODriverPwm.h MiCODriverRng.h MiCODriverRtc.h MiCODriverSpi.h MiCODriverUart.h MiCODriverWdg.h
  group libraries/daemons/http_server
    ../../../../libraries/daemons/http_server/: http-strings.c http_parse.c httpd.c httpd_handle.c httpd_ssi.c httpd_sys.c httpd_wsgi.c
  group libraries/Drivers/Button
    ../../../../libraries/drivers/keypad/gpio_button/: button.c
  group libraries/Drivers/MFiAuth
    ../../../../libraries/drivers/MiCODriverMFiAuth/: MiCODriverMFiAuth.a
  group libraries/Drivers/SPI Flash
    ../../../../libraries/drivers/spi_flash/: spi_flash.c spi_flash_platform.c
  group libraries/Drivers/STM32_USB_Host_Library/Class/MSC
    ../../../../Platform/Drivers/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
  group libraries/Drivers/STM32_USB_Host_Library/Core
    ../../../../Platform/Drivers/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
  group libraries/utilities
    ../../../../libraries/utilities/: AESUtils.c CheckSumUtils.c HTTPUtils.c RingBufferUtils.c SecurityUtils.c SHAUtils.c SocketUtils.c StringUtils.c TimeUtils.c TLVUtils.c URLUtils.c
  group libraries/utilities/base64
    ../../../../libraries/utilities/base64/: base64.c
  group libraries/utilities/jscon_c
    ../../../../libraries/utilities/json_c/: arraylist.c arraylist.h bits.h config.h json.h json_debug.c json_debug.h json_inttypes.h json_object.c json_object.h json_object_private.h json_tokener.c json_tokener.h json_util.c json_util.h linkhash.c linkhash.h printbuf.c printbuf.h
  group mico/core
    ../../../../MiCO/core/: MiCO.1062.SDIO.Cortex-M3.IAR.a MiCO.1062.SPI.Cortex-M3.IAR.a mico_config.c
    ../../../../MiCO/core/rf_driver/: wlan_firmware.c
  group mico/net/LwIP/mico
    ../../../../MiCO/net/LwIP/mico/: mico_socket.c
  group mico/RTOS
    ../../../../MiCO/RTOS/: mico_rtos_common.c
  group mico/RTOS/FreeRTOS/mico
    ../../../../MiCO/RTOS/FreeRTOS/mico/: mico_rtos.c
  group mico/RTOS/FreeRTOS/ver9.0.0
    ../../../../MiCO/RTOS/FreeRTOS/ver9.0.0/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../../MiCO/RTOS/FreeRTOS/ver9.0.0/Source/portable/MemMang/: heap_3.c
    ../../../../MiCO/RTOS/FreeRTOS/ver9.0.0/Source/portable/IAR/ARM_CM3/: port.c portasm.s
  group mico/security
    ../../../../MiCO/security/Sodium/: Lib_Sodium.IAR.release.a
    ../../../../MiCO/security/SRP_6a/: Lib_SRP6a.IAR.release.a
  group mico/security/curve25519
    ../../../../MiCO/security/Curve25519/: curve25519-donna.c
  group mico/security/SHA
    ../../../../MiCO/security/SHAUtils/: hkdf.c hmac.c sha1.c sha224-256.c sha384-512.c usha.c
  group mico/security/TLS
    ../../../../MiCO/security/TLS/wolfSSL/: Lib_wolfSSL.Cortex-M3.IAR.release.a
  group mico/system
    ../../../../MiCO/system/config_server/: config_server.c config_server_menu.c
    ../../../../MiCO/system/command_console/: mico_cli.c mico_cli.h
    ../../../../MiCO/system/: mico_system_init.c mico_system_monitor.c mico_system_notification.c mico_system_para_storage.c mico_system_power_daemon.c mico_system_time.c system.h system_misc.c
    ../../../../MiCO/system/tftp_ota/: tftp.h tftp_ota.c tftp_ota.h tftpc.o
  group mico/system/easylink
    ../../../../MiCO/system/easylink/airkiss_discovery/: airkiss_discovery.c
    ../../../../MiCO/system/easylink/MFi_WAC/: Lib_MFi_WAC.Cortex-M3.IAR.release.a
    ../../../../MiCO/system/easylink/airkiss_discovery/lib_airkiss/: libairkiss.a
    ../../../../MiCO/system/easylink/: system_easylink.c system_easylink_delegate.c system_easylink_wac.c
  group mico/system/mdns
    ../../../../MiCO/system/mdns/: mico_mdns.c mico_mdns.h system_discovery.c
  group mico/system/qc_test
    ../../../../MiCO/system/qc_test/: qc_test.c
    ../../../../MiCO/system/qc_test/internal/: qc_test_cli.c qc_test_gpio.c qc_test_tcpip.c
  group Platform/Cortex-M3
    ../../../../platform/Cortex-M3/: crt0_EWARM.c hardfault.c platform_core.c
  group Platform/EWARM
    ../../../../platform/EWARM/: Retarget.c
  group Platform/MCU
    ../../../../platform/MCU/: mico_platform_common.c platform_nsclock.c wlan_platform_common.c
  group Platform/MCU/STM32F2xx
    ../../../../platform/MCU/STM32F2xx/: platform_init.c
  group Platform/MCU/STM32F2xx/EWARM
    ../../../../platform/MCU/STM32F2xx/EWARM/: startup_stm32f2xx_EWARM.s
  group Platform/MCU/STM32F2xx/Peripherals
    ../../../../platform/MCU/STM32F2xx/peripherals/: platform_adc.c platform_flash.c platform_gpio.c platform_i2c.c platform_mcu_powersave.c platform_pwm.c platform_rng.c platform_rtc.c platform_spi.c platform_uart.c platform_watchdog.c
  group Platform/MCU/STM32F2xx/Peripherals/Libraries/STM32F2xx_HAL_Driver
    ../../../../platform/MCU/STM32F2xx/peripherals/libraries/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal.c stm32f2xx_hal_hcd.c stm32f2xx_ll_usb.c
  group Platform/MCU/STM32F2xx/Peripherals/Libraries/STM32F2xx_StdPeriph_Driver
    ../../../../platform/MCU/STM32F2xx/peripherals/libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
  group Platform/MCU/STM32F2xx/wlan_bus_driver
    ../../../../platform/MCU/STM32F2xx/wlan_bus_driver/: wlan_bus_SDIO.c wlan_bus_SPI.c wlan_platform.c
