# IAR project demo.ewp, settings and files
configuration MiCOKit-LPC5410x (ARM)
  General.OGChipSelectEditMenu: LPC54102J512_M4 NXP LPC54102J512_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; DEBUG; HSE_VALUE=16000000; CORE_M4; MXCHIP; FreeRTOS_VERSION="9.0.0"; LwIP_VERSION_MAJOR=1; LwIP_VERSION_MINOR=4; WOLFSSL_IAR_ARM; FreeRTOS_VERSION_MAJOR=9
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\demos\application\wifi_uart; ..\..\..\..\include; ..\..\..\..\External; ..\..\..\..\Board\MKLPC5410x; ..\..\..\..\Platform\include; ..\..\..\..\Platform\Cortex-M4; ..\..\..\..\Platform\Cortex-M4\CMSIS; ..\..\..\..\Platform\MCU\LPC5410x\peripherals; ..\..\..\..\Platform\MCU\LPC5410x\peripherals\Libraries; ..\..\..\..\libraries\Drivers\spi_flash; ..\..\..\..\libraries\Drivers\MiCOKit_EXT; ..\..\..\..\MICO; ..\..\..\..\libraries; ..\..\..\..\libraries\protocols; ..\..\..\..\libraries\utilities; ..\..\..\..\MICO\system; ..\..\..\..\MICO\system\command_console; ..\..\..\..\mico\system\qc_test\internal; ..\..\..\..\mico\system\qc_test; ..\..\..\..\mico\security; ..\..\..\..\libraries\Drivers; ..\..\..\..\MiCO\RTOS\FreeRTOS\mico\Cortex-M3; ..\..\..\..\MiCO\RTOS\FreeRTOS\mico; ..\..\..\..\MiCO\RTOS\FreeRTOS\ver9.0.0; ..\..\..\..\MiCO\RTOS\FreeRTOS\ver9.0.0\Source\include; ..\..\..\..\MiCO\RTOS\FreeRTOS\ver9.0.0\Source\portable\IAR\ARM_CM4F; ..\..\..\..\MiCO\RTOS; ..\..\..\..\platform\MCU\LPC5410x; ..\..\..\..\MiCO\net\LwIP\ver1.4.0.rc1\src\include; ..\..\..\..\MiCO\net\LwIP\ver1.4.0.rc1\src\include\ipv4; ..\..\..\..\platform; ..\..\..\..\libraries\daemons\homekit_server; ..\..\..\..\libraries\daemons\http_server; ..\..\..\..\libraries\utilities\base64
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\..\MiCO\RTOS\FreeRTOS\ver9.0.0; ..\..\..\..\MiCO\RTOS\FreeRTOS\ver9.0.0\Source\portable\IAR\ARM_CM4F; ..\..\..\..\MiCO\RTOS\FreeRTOS\mico\Cortex-M3; ..\..\..\..\MiCO\RTOS\FreeRTOS\mico; ..\..\..\..\board\MKLPC5410x
  OBJCOPY.OOCOutputFile: demo.bin
  ILINK.IlinkOutputFile: demo.out
  ILINK.IlinkIcfFile: ..\..\..\..\Board\MKLPC5410x\micoLinkerForIAR.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../../../../demos/application/wifi_uart/: cfunctions.c cfunctions.h cppfunctions.h LocalTcpServer.c mico_config.h MICOAppDefine.h MICOAppEntrance.c MICOBonjour.c RemoteTcpClient.c SppProtocol.c SppProtocol.h UartRecv.c
  group Board/MiCOKit-LPC5410x
    ../../../../board/MKLPC5410x/: platform.c platform.h platform_config.h
  group include
    ../../../../include/: common.h mico.h MicoAES.h MicoAlgorithm.h MicoPlatform.h MICORTOS.h MicoSocket.h MiCOSRPServer.h MicoWlan.h
  group include/MicoDriver
    ../../../../include/MiCODrivers/: MiCODriverAdc.h MiCODriverGpio.h MiCODriverI2c.h MiCODriverMFiAuth.h MiCODriverPwm.h MiCODriverRng.h MiCODriverRtc.h MiCODriverSpi.h MiCODriverUart.h MiCODriverWdg.h
  group libraries/daemons/homekit_server
    ../../../../libraries/daemons/homekit_server/: Lib_HomeKit_Server.Cortex-M4F.IAR.release.a
  group libraries/daemons/http_server
    ../../../../libraries/daemons/http_server/: http-strings.c http_parse.c httpd.c httpd_handle.c httpd_ssi.c httpd_sys.c httpd_wsgi.c
  group libraries/Drivers/display/VGM128064
    ../../../../libraries/drivers/display/VGM128064/: AsciiLib.c AsciiLib.h oled.c oled.h oledfont.h
  group libraries/Drivers/keypad/gpio_button
    ../../../../libraries/drivers/keypad/gpio_button/: button.c button.h
  group libraries/Drivers/led/P9813
    ../../../../libraries/drivers/rgb_led/P9813/: hsb2rgb_led.c hsb2rgb_led.h rgb_led.c rgb_led.h
  group libraries/Drivers/MFiAuth
    ../../../../libraries/drivers/MiCODriverMFiAuth/: MiCODriverMFiAuth.a
  group libraries/Drivers/MiCOKit-EXT
    ../../../../libraries/drivers/MiCOKit_EXT/: micokit_ext.c micokit_ext.h micokit_ext_def.h micokit_ext_mfg.c motion_sensor.c motion_sensor.h temp_hum_sensor.c
  group libraries/Drivers/MiCOKit-STmem
    ../../../../libraries/drivers/MiCOKit_STmems/: MiCOKit_STmems.c MiCOKit_STmems.h MiCOKit_STmems_def.h
  group libraries/Drivers/motor/dc_motor
    ../../../../libraries/drivers/motor/dc_motor/: dc_motor.c dc_motor.h
  group libraries/Drivers/sensor/ADPS9930
    ../../../../libraries/drivers/sensor/APDS9930/: APDS9930.c APDS9930.h
  group libraries/Drivers/sensor/BMA2x2
    ../../../../libraries/drivers/sensor/BMA2x2/: bma2x2.c bma2x2.h bma2x2_user.c bma2x2_user.h
  group libraries/Drivers/sensor/BME280
    ../../../../libraries/drivers/sensor/BME280/: bme280.c bme280.h bme280_user.c bme280_user.h
  group libraries/Drivers/sensor/BMG160
    ../../../../libraries/drivers/sensor/BMG160/: bmg160.c bmg160.h bmg160_user.c bmg160_user.h
  group libraries/Drivers/sensor/BMM050
    ../../../../libraries/drivers/sensor/BMM050/: bmm050.c bmm050.h bmm050_user.c bmm050_user.h
  group libraries/Drivers/sensor/DHT11
    ../../../../libraries/drivers/sensor/DHT11/: DHT11.c DHT11.h
  group libraries/Drivers/sensor/HTS221
    ../../../../libraries/drivers/sensor/HTS221/: hts221.c hts221.h
  group libraries/Drivers/sensor/infrared_adc
    ../../../../libraries/drivers/sensor/infrared_adc/: infrared_reflective.c infrared_reflective.h
  group libraries/Drivers/sensor/light_adc
    ../../../../libraries/drivers/sensor/light_adc/: light_sensor.c light_sensor.h
  group libraries/Drivers/sensor/LPS25HB
    ../../../../libraries/drivers/sensor/LPS25HB/: lps25hb.c lps25hb.h
  group libraries/Drivers/sensor/LSM9DS1
    ../../../../libraries/drivers/sensor/LSM9DS1/: lsm9ds1.h lsm9ds1_acc_gyr.c lsm9ds1_mag.c
  group libraries/Drivers/sensor/UVIS25
    ../../../../libraries/drivers/sensor/UVIS25/: uvis25.c uvis25.h
  group libraries/Drivers/SPI Flash
    ../../../../libraries/drivers/spi_flash/: spi_flash.c spi_flash_platform.c
  group libraries/utilities
    ../../../../libraries/utilities/: AESUtils.c CheckSumUtils.c HTTPUtils.c LinkListUtils.c RingBufferUtils.c SecurityUtils.c SHAUtils.c SocketUtils.c StringUtils.c TimeUtils.c TLVUtils.c URLUtils.c
  group libraries/utilities/base64
    ../../../../libraries/utilities/base64/: base64.c
  group libraries/utilities/json_c
    ../../../../libraries/utilities/json_c/: arraylist.c arraylist.h bits.h config.h debug.h json.h json_debug.c json_inttypes.h json_object.c json_object.h json_object_private.h json_tokener.c json_tokener.h json_util.c json_util.h linkhash.c linkhash.h printbuf.c printbuf.h
  group mico/core
    ../../../../MiCO/core/: MiCO.1062.SPI.Cortex-M4.IAR.a mico_config.c
    ../../../../MiCO/core/rf_driver/: wlan_firmware.c
  group mico/net/LwIP/mico
    ../../../../MiCO/net/LwIP/mico/: mico_socket.c
  group mico/RTOS
    ../../../../MiCO/RTOS/: mico_rtos_common.c
  group mico/RTOS/FreeRTOS/mico
    ../../../../MiCO/RTOS/FreeRTOS/mico/: mico_rtos.c
  group mico/RTOS/FreeRTOS/ver9.0.0
    ../../../../MiCO/RTOS/FreeRTOS/ver9.0.0/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../../MiCO/RTOS/FreeRTOS/ver9.0.0/Source/portable/MemMang/: heap_3.c
    ../../../../MiCO/RTOS/FreeRTOS/ver9.0.0/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group mico/security
    ../../../../MiCO/security/Sodium/: Lib_Sodium.IAR.release.a
    ../../../../MiCO/security/SRP_6a/: Lib_SRP6a.IAR.release.a
  group mico/security/curve25519
    ../../../../MiCO/security/Curve25519/: curve25519-donna.c
  group mico/security/SHA
    ../../../../MiCO/security/SHAUtils/: hkdf.c hmac.c sha1.c sha224-256.c sha384-512.c usha.c
  group mico/security/TLS
    ../../../../MiCO/security/TLS/wolfSSL/: Lib_wolfSSL.Cortex-M4F.IAR.release.a
  group mico/system
    ../../../../MiCO/system/config_server/: config_server.c config_server_menu.c
    ../../../../MiCO/system/command_console/: mico_cli.c mico_cli.h
    ../../../../MiCO/system/: mico_system_init.c mico_system_monitor.c mico_system_notification.c mico_system_para_storage.c mico_system_power_daemon.c mico_system_time.c system.h system_misc.c
    ../../../../MiCO/system/tftp_ota/: tftp.h tftp_ota.c tftp_ota.h tftpc.o
  group mico/system/easylink
    ../../../../MiCO/system/easylink/airkiss_discovery/: airkiss_discovery.c
    ../../../../MiCO/system/easylink/MFi_WAC/: Lib_MFi_WAC.Cortex-M4F.IAR.release.a
    ../../../../MiCO/system/easylink/airkiss_discovery/lib_airkiss/: libairkiss.a
    ../../../../MiCO/system/easylink/: system_easylink.c system_easylink_delegate.c system_easylink_wac.c
  group mico/system/mdns
    ../../../../MiCO/system/mdns/: mico_mdns.c mico_mdns.h system_discovery.c
  group mico/system/qc_test
    ../../../../MiCO/system/qc_test/: qc_test.c
    ../../../../MiCO/system/qc_test/internal/: qc_test_cli.c qc_test_gpio.c qc_test_internal.h qc_test_tcpip.c
  group Platform
    ../../../../platform/MCU/: mico_platform_common.c wlan_platform_common.c
  group Platform/Cortex-M4
    ../../../../platform/Cortex-M4/: crt0_EWARM.c hardfault.c platform_core.c
  group Platform/EWARM
    ../../../../platform/EWARM/: Retarget.c
  group Platform/LPC5410x
    ../../../../platform/MCU/LPC5410x/: platform_init.c
  group Platform/LPC5410x/EWARM
    ../../../../platform/MCU/LPC5410x/EWARM/: startup_lpc54100_EWARM.s
  group Platform/LPC5410x/Peripherals
    ../../../../platform/MCU/LPC5410x/peripherals/: platform_adc.c platform_flash.c platform_gpio.c platform_i2c.c platform_mcu_peripheral.h platform_mcu_powersave.c platform_nano_second.c platform_pwm.c platform_rng.c platform_rtc.c platform_spi.c platform_uart.c platform_watchdog.c
  group Platform/LPC5410x/Peripherals/Libraries
    ../../../../platform/MCU/LPC5410x/peripherals/Libraries/: adc_5410x.c chip_5410x.c clock_5410x.c crc_5410x.c dma_5410x.c fifo_5410x.c fpu_init.c gpio_5410x.c gpiogroup_5410x.c i2c_common_5410x.c i2cm_5410x.c i2cs_5410x.c iap.c iocon_5410x.c pinint_5410x.c pll_5410x.c power_control.c ring_buffer.c ritimer_5410x.c rtc_5410x.c rtc_ut.c sct_5410x.c sct_pwm_5410x.c spi_5410x.c spi_common_5410x.c spim_5410x.c spis_5410x.c stopwatch_5410x.c syscon_5410x.c sysinit_5410x.c timer_5410x.c uart_5410x.c utick_5410x.c wwdt_5410x.c
  group Platform/LPC5410x/Wi-Fi_Bus_Driver
    ../../../../platform/MCU/LPC5410x/wlan_bus_driver/: wlan_bus_SPI.c wlan_platform.c
