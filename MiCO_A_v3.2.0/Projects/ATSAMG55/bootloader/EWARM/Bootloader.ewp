# IAR project Bootloader.ewp, settings and files
configuration MiCOKit-G55 (ARM)
  General.OGChipSelectEditMenu: ATSAMG55J19 Atmel ATSAMG55J19
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAMG55J19__; ARM_MATH_CM4=true; BOARD=USER_BOARD; DEBUG; BOOTLOADER; NO_MICO_RTOS; MICO_NO_WIFI
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\Bootloader; ..\..\..\..\include; ..\..\..\..\MICO; ..\..\..\..\Board\MKG55; ..\..\..\..\Platform\include; ..\..\..\..\Platform\Cortex-M4; ..\..\..\..\Platform\Cortex-M4\CMSIS; ..\..\..\..\Platform\MCU; ..\..\..\..\Platform\MCU\ATSAMG55\peripherals; ..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries; ..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\utils\cmsis\samg\samg55\include; ..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\services\flash_efc; ..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\drivers\pio; ..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\drivers\usart; ..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\drivers\spi; ..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\drivers\efc; ..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\drivers\pmc; ..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\drivers\pdc; ..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\drivers\wdt; ..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\drivers\flexcom; ..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\common\services\ioport; ..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\common\services\clock; ..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\common\utils; ..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\utils; ..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\utils\cmsis\samg\samg55\include\instance; ..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\utils\preprocessor; ..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\utils\header_files; ..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\utils\cmsis\samg\samg55\include; ..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\common\services\sleepmgr; ..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\common\boards; ..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\drivers\twi; ..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\drivers\adc; ..\..\..\..\libraries\utilities; ..\..\..\..\mico\system; ..\..\..\..\mico\security; ..\..\..\..\libraries\drivers\MiCOKit_EXT; ..\..\..\..\libraries\drivers\spi_flash; ..\..\..\..\libraries\drivers; ..\..\..\..\platform
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Bootloader.bin
  ILINK.IlinkOutputFile: COM.MXCHIP.SPP.out
  ILINK.IlinkIcfFile: ..\..\..\..\Board\MKG55\bootloaderLinkerForIAR.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Board/MiCOKit-G55
    ../../../../board/MKG55/: platform.c platform.h platform_config.h
  group Bootloader
    ../../../../bootloader/: BootloaderEntrance.c Getline.c menu.c Update_for_OTA.c ymodem.c
    ../../../../Bootloader/: MicoDefaults.h
  group include
    ../../../../include/: mico.h MicoAES.h MicoAlgorithm.h MicoPlatform.h MICORTOS.h MicoSocket.h MiCOSRPServer.h MicoWlan.h
  group include/MicoDriver
    ../../../../include/MiCODrivers/: MiCODriverAdc.h MiCODriverGpio.h MiCODriverI2c.h MiCODriverMFiAuth.h MiCODriverPwm.h MiCODriverRng.h MiCODriverRtc.h MiCODriverSpi.h MiCODriverUart.h MiCODriverWdg.h
  group libraries/Driver/SPI Flash
    ../../../../libraries/drivers/spi_flash/: spi_flash.c spi_flash_platform.c
  group libraries/utilities
    ../../../../libraries/utilities/: CheckSumUtils.c RingBufferUtils.c StringUtils.c
  group mico
    ../../../../MiCO/RTOS/NoRTOS/: rtos.c
  group Platform/Cortex-M4
    ../../../../platform/Cortex-M4/: crt0_EWARM.c hardfault.c
  group Platform/EWARM
    ../../../../platform/EWARM/: Retarget.c
  group Platform/MCU
    ../../../../platform/MCU/: mico_platform_common.c wlan_platform_common.c
  group Platform/MCU/STSAMG55
    ../../../../platform/MCU/ATSAMG55/: platform_init.c
  group Platform/MCU/STSAMG55/EWARM
    ../../../../platform/MCU/ATSAMG55/EWARM/: startup_ATSAMG55_bootloader_EWARM.s
  group Platform/MCU/STSAMG55/Peripherals
    ../../../../platform/MCU/ATSAMG55/peripherals/: platform_adc.c platform_flash.c platform_gpio.c platform_i2c.c platform_mcu_peripheral.h platform_mcu_powersave.c platform_nano_second.c platform_pwm.c platform_rng.c platform_rtc.c platform_spi.c platform_uart.c platform_watchdog.c
  group Platform/MCU/STSAMG55/Peripherals/Libraries/asf-3.22.0/common
    ../../../../Platform/MCU/ATSAMG55/peripherals/Libraries/common/utils/interrupt/: interrupt_sam_nvic.c
  group Platform/MCU/STSAMG55/Peripherals/Libraries/asf-3.22.0/common/services/clock
    ../../../../platform/MCU/ATSAMG55/peripherals/Libraries/asf-3.22.0/common/services/clock/samg/: sysclk.c
  group Platform/MCU/STSAMG55/Peripherals/Libraries/asf-3.22.0/common/services/sleepmgr
    ../../../../platform/MCU/ATSAMG55/peripherals/Libraries/asf-3.22.0/common/services/sleepmgr/sam/: sleepmgr.c
  group Platform/MCU/STSAMG55/Peripherals/Libraries/asf-3.22.0/common/utils/interrupt
    ../../../../platform/MCU/ATSAMG55/peripherals/Libraries/asf-3.22.0/common/utils/interrupt/: interrupt_sam_nvic.c
  group Platform/MCU/STSAMG55/Peripherals/Libraries/asf-3.22.0/sam/drivers/adc
    ../../../../platform/MCU/ATSAMG55/peripherals/Libraries/asf-3.22.0/sam/drivers/adc/: adc2.c
  group Platform/MCU/STSAMG55/Peripherals/Libraries/asf-3.22.0/sam/drivers/efc
    ../../../../platform/MCU/ATSAMG55/peripherals/Libraries/asf-3.22.0/sam/drivers/efc/: efc.c
  group Platform/MCU/STSAMG55/Peripherals/Libraries/asf-3.22.0/sam/drivers/flexcom
    ../../../../platform/MCU/ATSAMG55/peripherals/Libraries/asf-3.22.0/sam/drivers/flexcom/: flexcom.c
  group Platform/MCU/STSAMG55/Peripherals/Libraries/asf-3.22.0/sam/drivers/pdc
    ../../../../platform/MCU/ATSAMG55/peripherals/Libraries/asf-3.22.0/sam/drivers/pdc/: pdc.c
  group Platform/MCU/STSAMG55/Peripherals/Libraries/asf-3.22.0/sam/drivers/pio
    ../../../../platform/MCU/ATSAMG55/peripherals/Libraries/asf-3.22.0/sam/drivers/pio/: pio.c
  group Platform/MCU/STSAMG55/Peripherals/Libraries/asf-3.22.0/sam/drivers/pmc
    ../../../../platform/MCU/ATSAMG55/peripherals/Libraries/asf-3.22.0/sam/drivers/pmc/: pmc.c sleep.c
  group Platform/MCU/STSAMG55/Peripherals/Libraries/asf-3.22.0/sam/drivers/spi
    ../../../../platform/MCU/ATSAMG55/peripherals/Libraries/asf-3.22.0/sam/drivers/spi/: spi.c
  group Platform/MCU/STSAMG55/Peripherals/Libraries/asf-3.22.0/sam/drivers/twi
    ../../../../platform/MCU/ATSAMG55/peripherals/Libraries/asf-3.22.0/sam/drivers/twi/: twi.c
  group Platform/MCU/STSAMG55/Peripherals/Libraries/asf-3.22.0/sam/drivers/usart
    ../../../../platform/MCU/ATSAMG55/peripherals/Libraries/asf-3.22.0/sam/drivers/usart/: usart.c
  group Platform/MCU/STSAMG55/Peripherals/Libraries/asf-3.22.0/sam/drivers/wdt
    ../../../../platform/MCU/ATSAMG55/peripherals/Libraries/asf-3.22.0/sam/drivers/wdt/: wdt.c
  group Platform/MCU/STSAMG55/Peripherals/Libraries/asf-3.22.0/sam/services/flash_efc
    ../../../../platform/MCU/ATSAMG55/peripherals/Libraries/asf-3.22.0/sam/services/flash_efc/: flash_efc.c
  group Platform/MCU/STSAMG55/Peripherals/Libraries/asf-3.22.0/sam/utils/cmsis
    ../../../../platform/MCU/ATSAMG55/peripherals/Libraries/asf-3.22.0/sam/utils/cmsis/samg/samg55/source/templates/: system_samg55.c
